# IAR project STM32F030CCT6_IR_ARRAY.ewp, settings and files
configuration STM32F030CCT6_IR_ARRAY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030xC; USE_LINUX_SYSTEM=0; USE_TCP_SEQUENS_NUM=0; ENABLE_MODBUS_DEBUG=0
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\MODBUS; ..\Drivers\8025T; ..\Drivers\SCREEN_1.8; ..\Drivers\CircularBUFF
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: STM32F030CCT6_IR_ARRAY.hex
  ILINK.IlinkOutputFile: STM32F030CCT6_IR_ARRAY.out
  ILINK.IlinkIcfFile: stm32f030xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030xc.s
  group Application/User
    ../Src/: dma.c freertos.c gpio.c i2c.c main.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_tim.c stm32f0xx_it.c usart.c
  group Drivers/8025T
    ../Drivers/8025T/: 8025t_drv.c
  group Drivers/CircularBUFF
    ../Drivers/CircularBUFF/: CircularQueue.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/MODBUS
    ../Drivers/MODBUS/: modbus_port.c modbus_reg.c task_master.c task_slave.c Utilities.c
  group Drivers/SCREEN_1.8
    ../Drivers/SCREEN_1.8/: SCREEN_1.8_drv.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
